# Keil uVision project project.uvprojx, settings and files
target Project (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER,STM32F103xB,
  c include: ..\Drivers\CMSIS\CM3\DeviceSupport\ST\STM32F10x\startup\arm;..\Drivers\STM32F10x_StdPeriph_Driver\inc;..\Drivers\STM32F10x_StdPeriph_Driver\src;..\Drivers\CMSIS\CM3\CoreSupport;..\Src;..\Inc;..\BSP;..\Middleware\User\RF;..\Middleware\User\Repeater;..\Middleware\User\Touch;..\Middleware\User\ZeroDetect;..\Common;..\Src;..\Params;..\HostComm;..\Debug
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT5: ROM 0x8010000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startup
    ../Drivers/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
  group Common
    ../Common/: timeout.c delay.c version.c common.c
  group Application/User
    ../Src/: main.c stm32f10x_it.c touch_man.c function.c
  group CMSIS
    ../Drivers/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../Drivers/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group StdPeriph_Driver
    ../Drivers/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_dma.c stm32f10x_i2c.c stm32f10x_usart.c
  group Driver/BSP
    ../BSP/: cap1214.c led.c adc.c relay.c buzzer.c
  group Middleware/User
    ../Middleware/User/Touch/: touch.c
    ../Middleware/User/ZeroDetect/: zdetect.c
  group Params
    ../Params/: params.c save.c
  group Debug
    ../Debug/: debug.c
